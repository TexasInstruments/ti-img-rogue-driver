## kernel/drivers/staging/imgtec/nulldisp/Kconfig
```kconfig
config POWERVR_NULLDISP
	tristate "DRM display driver for VNC viewing"
	default n
	depends on DRM
```
